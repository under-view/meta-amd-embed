require amd-linux-tiny.inc

LINUX_VERSION = "6.12.101"

SRCREV_amdmeta = "4a764f78530d7c5a3c40806af49803a4a5427455"
